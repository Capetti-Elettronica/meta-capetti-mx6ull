hostname = "gw25lx"